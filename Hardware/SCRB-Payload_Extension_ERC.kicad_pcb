# Repository space-concordia-robotics/SCRB-SP-27-00-02-ERC-Board

File README.md:

# SCRB-SP-27-00-02
Science Payload ERC Extension Board

## KiCad design Hardware/SCRB-Payload_Extension_ERC.kicad_pcb

File Hardware/README.md:

KiCad Hardware project of Science Payload ERC Board

Parts:
C1, C2, C7, C22, C27, C29, C30: 0.1u; C0402; Voltage 25V
C4: 47u; C0603; Voltage Voltage
C5: 1p; C0402; Voltage 16V
C6: 4.7u; C0603; Voltage 16V
C8, C12: 6.8nF; C0402; Voltage 25V
C9: 5.1n; C0402; Voltage 25V
C10, C11, C13, C17, C24, C26, C31, C39: 510p; C0402; Voltage 25V
C14: 0.1u; C0402; Voltage 50V
C15, C25, C38: 5.1nF; C0402; Voltage 25V
C16, C21: 12p; C0402; Voltage 25V
C18: 1u; C0402; Voltage 25V
C19: 4.7u; C0805; Voltage 50V
C20: 0.1u; C0402; Voltage 16V
C23, C32, C33, C36: 0.1u; C0402; Voltage 10V
C35: 2.2u; C0603; Voltage 16V
C37: 10nF; C0402; Voltage 25V
CR2: MMSZ5232BS-7-F; ZDO_SOD323_DIO
D2: SMBJ6.0CA; SMB
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
IC1: STM32C542CCT6; LQFP-48_7x7mm_P0.5mm; Manufacturer_Part_Number STM32C542CCT6
J1: Conn_UART; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J2, J4, J5, J6: Conn_LoadCell; JST_PH_B4B-PH-SM4-TB_1x04-1MP_P2.00mm_Vertical
J3: Conn_Nichrome; Molex_Micro-Fit_3.0_43650-0200_1x02_P3.00mm_Horizontal
J7: Conn_Therm; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
J8: ST-Link-Conn-SM; JST_PH_B4B-PH-SM4-TB_1x04-1MP_P2.00mm_Vertical
J9: Conn_6HIGH; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J11: Conn_5V; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
L1: 2.5u; IND_PCC-M1060ML_PAN
LD1, LD2: LED0603
LD3: 3V3_LED; LED0603
Q1: AO3400A; SOT-23
R1, R7, R27, R32: 10k; R0402
R2: 120; R0805
R3, R4, R9, R10, R11, R12, R26, R31, R43, R44: 470; R0402
R5, R6, R28: 100; R0402
R8: 4.7k; R0402
R13: 121k; R0402
R14: 54.9k; R0402
R15: 18k; R0402
R16: 30k; R0603
R17: 45.3k; R0603
R18: 100k; R0402
R19: 124k; R0402; not fitted
R20: R0805
R29: 680; R0402
R33, R34, R35, R36, R37, R38, R39, R40: 47; R0402
R41, R42: 4.7K; R0402
SB1: SB0402; JP0402_NO
SW1: SW_Oval; SW_C2888430
TP1, TP2, TP3: Testpoint; TestPoint_Loop_D2.60mm_Drill1.6mm_Beaded
TP4: TestPoint; TestPoint_Pad_D1.0mm
U1: TPS543x21; VQFN-HR9_RQF_TEX
U2, U8, U9, U10, U11, U12, U13, U14, U15, U16: TPD4E05U06DQAR; DQA0010A
U3: THVD1500DR; D0008A
U4, U5: ADS1220IPW; PW16
U6: TLV75533PDBV; SOT-23-5
U7: INA241A4IDDFR; DDF0008A
Y1: 16M, 9p; SMD3225

Connections:
/1V5: C4.1, C5.1, L1.2, R17.1, R20.1, U7.8 (IN+)
/3V3: C6.2, C7.1, C23.2, C29.1, C32.2, C33.2, IC1.24 (VDD_1), IC1.36 (VDD_2), IC1.48 (VDD_3), J8.1 (3V3), R7.1, R8.1, R29.1, SB1.2 (B), U4.13 (DVDD), U5.13 (DVDD), U8.5 (D4), U8.6 (NC)
/5V: C1.1, C2.1, C18.1, C27.1, C30.2, D2.2 (A2), J2.1, J4.1, J5.1, J6.1, J11.1, R18.1, R26.2, R41.1, R42.1, R43.2, U3.8 (VCC), U4.12 (AVDD), U5.12 (AVDD), U6.1 (IN), U6.3 (EN), U7.6 (VS), U9.2 (D2), U9.9 (NC), U10.2 (D2), U10.9 (NC), U11.2 (D2), U11.9 (NC), U12.2 (D2), U12.9 (NC)
/6_Hi: C14.1, C19.1, J9.1, R13.1, U1.5 (VIN), U1.6 (VIN)
/ADC_Therm: C37.1, IC1.11 (PA1), J7.1, R29.2
/AIN0_1: C9.1, C10.2, R3.2, U4.11 (AIN0/REFP1)
/AIN0_3: C24.2, C25.1, R9.2, U5.11 (AIN0/REFP1)
/AIN1_1: C9.2, C11.1, R4.2, U4.10 (AIN1)
/AIN1_3: C25.2, C26.1, R10.2, U5.10 (AIN1)
/AIN2_2: C13.2, C15.1, R5.2, U4.7 (AIN2)
/AIN2_4: C31.2, C38.1, R11.2, U5.7 (AIN2)
/AIN3_2: C15.2, C17.1, R6.2, U4.6 (AIN3/REFN1)
/AIN3_4: C38.2, C39.1, R12.2, U5.6 (AIN3/REFN1)
/CURR_VOUT: IC1.12 (PA2), U7.5 (OUT)
/DE: IC1.27 (PB14), R1.1, U3.2 (nRE), U3.3 (DE)
/E1-: J2.2, J4.2, R31.2, U9.4 (D3), U9.7 (NC), U10.4 (D3), U10.7 (NC)
/E3-: J5.2, J6.2, R44.2, U11.4 (D3), U11.7 (NC), U12.4 (D3), U12.7 (NC)
/EN: CR2.1, R13.2, R14.1, U1.2 (EN)
/GATE_SW: IC1.29 (PA8), R28.1
/LED_PANIK: IC1.2 (PC13), LD2.1 (K)
/LED_RUN: IC1.1 (PE2), LD1.1 (K)
/NRST: C20.1, IC1.7 (NRST), SW1.2
/Nichrome_Hi: J3.1, R20.2, U7.1 (IN-)
/Nichrome_LO: J3.2, Q1.3 (D), TP4.1 (1_1)
/RCC_OSC_IN: C16.2, IC1.5 (PH0-OSC_IN), Y1.1
/RCC_OSC_OUT: C21.1, IC1.6 (PH1-OSC_OUT), Y1.3
/REFN0: C8.2, R31.1, U4.8 (REFN0)
/REFN0_2: C12.2, R44.1, U5.8 (REFN0)
/REFP0: C8.1, R26.1, U4.9 (REFP0)
/REFP0_2: C12.1, R43.1, U5.9 (REFP0)
/RS485A: J1.2, R2.2, U2.4 (D3), U2.7 (NC), U3.6 (A)
/RS485B: J1.1, R2.1, U2.2 (D2), U2.9 (NC), U3.7 (B)
/SPI1_MISO: R36.2, U4.15 (DOUT/~DRDY)
/SPI1_MOSI: R34.1, U4.16 (DIN)
/SPI1_SCK: R35.2, TP3.1 (1_1), U4.1 (SCLK)
/SPI1_~CS: R33.2, U4.2 (~CS)
/SPI2_MISO: R37.2, U5.15 (DOUT/~DRDY)
/SPI2_MOSI: R39.2, U5.16 (DIN)
/SPI2_SCK: R40.2, TP2.1 (1_1), U5.1 (SCLK)
/SPI2_~CS: R38.2, U5.2 (~CS)
/SYS_SWDCLK: IC1.37 (PA14), J8.3 (SWCLK), U8.1 (D1), U8.10 (NC)
/SYS_SWDIO: IC1.34 (PA13), J8.2 (SWDIO), U8.2 (D2), U8.9 (NC)
/Sig1+: J4.3, R3.1, U13.2 (D2), U13.9 (NC)
/Sig1-: J4.4, R4.1, U13.4 (D3), U13.7 (NC)
/Sig2+: J2.3, R5.1, U14.2 (D2), U14.9 (NC)
/Sig2-: J2.4, R6.1, U14.4 (D3), U14.7 (NC)
/Sig3+: J5.3, R9.1, U15.2 (D2), U15.9 (NC)
/Sig3-: J5.4, R10.1, U15.4 (D3), U15.7 (NC)
/Sig4+: J6.3, R11.1, U16.2 (D2), U16.9 (NC)
/Sig4-: J6.4, R12.1, U16.4 (D3), U16.7 (NC)
/UART_RX: IC1.25 (PB12), R42.2, U3.1 (R)
/UART_TX: IC1.26 (PB13), R41.2, U3.4 (D)
/ldo_3V3: C22.1, R32.1, SB1.1 (A), U6.5 (OUT)
GND: C1.2, C2.2, C4.2, C6.1, C7.2, C10.1, C11.2, C13.1, C14.2, C16.1, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, C24.1, C26.2, C27.2, C29.2, C30.1, C31.1, C32.1, C33.1, C35.2, C36.2, C37.2, C39.2, CR2.2, D2.1 (A1), IC1.8 (VREF-), IC1.23 (VSS_1), IC1.35 (VSS_2), IC1.47 (VSS_3), J1.3, J7.2, J8.4 (GND), J9.2, J11.2, LD3.1 (K), Q1.2 (S), R1.2, R14.2, R15.2, R16.2, R19.1, R27.2, SW1.1, U1.4 (GND), U2.3 (GND), U2.8 (GND), U3.5 (GND), U4.3 (CLK), U4.4 (DGND), U4.5 (AVSS), U5.3 (CLK), U5.4 (DGND), U5.5 (AVSS), U6.2 (GND), U7.2 (GND), U7.3 (REF2), U7.4 (NC), U7.7 (REF1), U8.3 (GND), U8.8 (GND), U9.3 (GND), U9.8 (GND), U10.3 (GND), U10.8 (GND), U11.3 (GND), U11.8 (GND), U12.3 (GND), U12.8 (GND), U13.3 (GND), U13.8 (GND), U14.3 (GND), U14.8 (GND), U15.3 (GND), U15.8 (GND), U16.3 (GND), U16.8 (GND), Y1.2, Y1.4
unnamed: IC1.16 (PA6), R36.1
unnamed: IC1.17 (PA7), R37.1
unnamed: IC1.38 (PA15), R33.1
unnamed: IC1.19 (PB1), R38.1
unnamed: IC1.20 (PB2), R39.1
unnamed: IC1.39 (PB3), R35.1
unnamed: IC1.21 (PB10), R40.1
unnamed: IC1.28 (PB15), R34.2
unnamed: C35.1, IC1.22 (VCAP)
unnamed: C36.1, IC1.9 (VREF+)
unnamed: LD1.2 (A), R7.2
unnamed: LD2.2 (A), R8.2
unnamed: LD3.2 (A), R32.2
unnamed: Q1.1 (G), R27.1, R28.2, TP1.1 (1_1)
unnamed: C5.2, R16.1, R17.2, U1.3 (FB)
unnamed: R15.1, U1.7 (MODE)
unnamed: R19.2, U1.1 (RT/SYNC)
unnamed: R18.2, U1.9 (SS/PG)
unnamed: L1.1, U1.8 (SW)

Notes on the sheet:
RFBT = RFBB * (Vout - Vref)/Vref = 30k * (1.5V - 0.6V)/0.6V = 45k
Buck Converter for Heating Element
ST-Link
ADC - Load Cell Analog Signal to MCU
3 OF THESE
ʕっ•ᴥ•ʔっ
Heating Element
UART Transceiver
⠀⠀⠀⠀⠀⠀⠀⢀⣀⡤⠴⠶⠶⠒⠲⠦⢤⣀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀ ⠀⠀⠀⠀⢀⡠⠞⠋⠀⠀⠀⠀⠀⠀⠀⠀⠀⠈⠉⠲⠤⣄⡀⠀⠀⠀⠀⠀ ⠀⠀⣀⡴⠋⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⣤⡿⠀⠀⠀⠀⠀ ⠀⢾⣅⡀⠀⠀⠀⠀⣀⠀⠀⠀⠀⠀⠀⢀⡦⠤⠄⠀⠀⢻⡀⠀⠀⠀⠀⠀ ⠀⠈⢹⡏⠀⠀⠐⠋⠉⠁⠀⠻⢿⠟⠁⠀⠀⢤⠀⠀⠠⠤⢷⣤⣤⢤⡄⠀ ⠀⠀⣼⡤⠤⠀⠀⠘⣆⡀⠀⣀⡼⠦⣄⣀⡤⠊⠀⠀⠀⠤⣼⠟⠀⠀⢹⡂ ⠀⠊⣿⡠⠆⠀⠀⠀⠈⠉⠉⠙⠤⠤⠋⠀⠀⠀⠀⠀⠀⡰⠋⠀⠀⠀⡼⠁ ⠀⢀⡾⣧⡀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠜⠁⠀⠀⠀⣸⠁⠀ ⠀⠀⠀⡼⠙⠢⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⣰⠃⠀⠀ ⠀⢀⡞⠁⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⠀⣰⠃⠀⠀⠀ ⠀⡼⠀⠀⠀⠀⠀⠀⠀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
≽^•⩊•^≼
LDO
MCU
change this there is 4 of them
First order differential, common-mode RC filter: f_cMAX = f_MOD/10 = 256kHz/10 = 25.6kHz Load cell specs: R_in = 405 | R_out = 350 | Excitation = 5V R_F1 <= 1k -> R_F1,2 = 470 C_DIF1 = 1/(2π * (350+470+470) * 25.6kHz) = 4.82nF -> 5.1nF C_CM1,2 = C_DIF1/10 = 510Pf C_DIF2 = 1/(2π * 940 * 24.2kHz) = 6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
RS-485 - ERC Board to Main Payload Board
UVLO = 3.77 V

Board: 4 copper layers, 81.1 x 57.3 mm, 119 parts (0 on the bottom side), 73 nets.
